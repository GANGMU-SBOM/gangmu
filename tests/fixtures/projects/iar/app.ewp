# IAR project app.ewp, settings and files
configuration Debug (ARM)
configuration Release (ARM)
  as the first configuration, except:
  group Application
    ../../project/src/: main.c debug_only.c never_built.c
  group tinynet
    ../../project/components/net/tinynet/src/: core.c buf.c
    $TOOLKIT_DIR$/inc/c/: DLib_Config_Normal.h
